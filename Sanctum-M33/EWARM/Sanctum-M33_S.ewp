# IAR project Sanctum-M33_S.ewp, settings and files
configuration Sanctum-M33_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32U545RE ST STM32U545RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U545xx
  ICCARM.CCIncludePath2: ../Secure/Core/Inc; ../Secure_nsclib; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sanctum-M33_S.hex
  ILINK.IlinkOutputFile: Sanctum-M33_S.out
  ILINK.IlinkIcfFile: stm32u545xx_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u545xx.s
  group Application/User/Secure/Core
    ../Secure/Core/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c secure_nsc.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_icache.c
  group Drivers/CMSIS
    ../Secure/Core/Src/: system_stm32u5xx_s.c
